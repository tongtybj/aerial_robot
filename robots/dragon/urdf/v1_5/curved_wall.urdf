Commit message: Add impedance control for dragon

File: robots/dragon/urdf/v1_5/curved_wall.urdf (robot description, URDF)
Before this commit: robot curved_wall, 1 links, 0 joints
Links:
- link curved_wall: geometry collision cylinder length=2 radius=1.2; visual cylinder length=2 radius=1.2
